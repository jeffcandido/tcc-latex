options:
  parameters:
    author: Jefferson da Silva Cândido
    copyright: Public-domain
    generate_options: qt_gui
    id: exemplo_ao_quadrado
    output_language: python
    title: Segunda Potência
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '50'
    min: '0'
    num_samps: '32'
    repeat: 'True'
    type: int
  states: {}
- name: blocks_float_to_int_0
  id: blocks_float_to_int
  parameters:
    scale: '1'
  states: {}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: int
  states: {}
- name: exemplo_ao_quadrado_ff_0
  id: exemplo_ao_quadrado_ff
  parameters: {}
  states: {state: disabled}
- name: howto_square2_ff_0
  id: howto_square2_ff
  parameters: {}
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Exemplo GNURadio"'
    nconnections: '2'
    type: int
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_float_to_int_0, '0', qtgui_number_sink_0, '1']
- [blocks_int_to_float_0, '0', exemplo_ao_quadrado_ff_0, '0']
- [blocks_int_to_float_0, '0', howto_square2_ff_0, '0']
- [blocks_throttle_0, '0', blocks_int_to_float_0, '0']
- [blocks_throttle_0, '0', qtgui_number_sink_0, '0']
- [exemplo_ao_quadrado_ff_0, '0', blocks_float_to_int_0, '0']
- [howto_square2_ff_0, '0', blocks_float_to_int_0, '0']

metadata:
  file_format: 1
